# Keil uVision project USART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IMU_Module +hex
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Startup/: cortexm3_macro.s stm32f10x_vector.s
  group main
    ./Source/: main.c stm32f10x_it.c uart.c MPU6050.c
  group FWlib
    ./FWLib/src/: stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_i2c.c stm32f10x_tim.c
